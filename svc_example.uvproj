# Keil uVision project svc_example.uvproj, settings and files
target svc_example-EKTM4C1294XL (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: svc_example
  c flags: Optim=4 uC99=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT
  c include: .;.\util;.\TivaWare;.\SysProcessor;.\PrecisionTimer;.\uniquecount
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src
    ./: startup_rvmdk.s error.c main.c SVC.c
  group TivaWare/driverlib
    ./TivaWare/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
  group TivaWare/inc
    ./TivaWare/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c1294ncpdt.h
  group SysProcessor
    ./SysProcessor/: SysProcessor.c SysProcessor.h
  group PrecisionTimer
    ./PrecisionTimer/: TTimer.c TTimer.h
  group util
    ./util/: util.c util.h
  group header
    ./: defs.h errno.h main.h
  group UniqueCount
    ./uniquecount/: uniquecount.c uniquecount.h
target TTimerExample-DKTM4C123G (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TTimerExample
  c flags: Optim=4 uC99=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE
  c include: .;.\util;.\TivaWare;.\SysProcessor;.\PrecisionTimer
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
